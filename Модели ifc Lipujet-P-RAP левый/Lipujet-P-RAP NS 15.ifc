Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-23T14:41:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 14:41:21 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{DFCEA5ED-26AA-4A0A-B4ED-81F8CCB2F408}\ifc * Database version: 5507 * Database creation date: Tue May 23 14:41:19 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 14:41:19 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 14:41:19 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowController: std, ZZZ_do not use_ME_ST_filling device for Ecojet_ACO:std:20035
In: Level 1
Type - Description: Filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: Filling device; LOD: LOD 400; Manufacturer: ACO; Model: ACO filling device for Ecojet; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO
Type - Plumbing - p_c01_flow: 0.105944 m3/s
Type - Structural - RSen_S_net_mass: 3.5
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Offset: 2183 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
Identity Data - Mark: 12; RSen_C_code_article: 3300.11.22; RSen_C_code_gtin: 04002626299253; RSen_C_description: ACO Fülleinheit für Eco-Jet-O,-OD,-R,-RD
Other - option: 0; Family: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Family and Type: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Type: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Type Id: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowTerminal: NS15, ME_PE_hydro jet rae extension stage 3_ACO:NS15:20027
In: Level 1
Type - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; PredefinedType: GREASEINTERCEPTOR; Material: Steel, Blue, HDPE, Black, PVC, White, Stainless Steel, Brushed
Type - Electrical - Loads - RSen_E_c01_load_classification: Power; RSen_E_powerfactor: 1
Type - Electrical Engineering - RSen_E_c01_3_phase: yes; RSen_E_c01_current: 16 A; RSen_E_c01_number_of_poles: 3; RSen_E_c01_subclass_motor: yes; RSen_E_c01_voltage: 400 V
Type - General - installation_manual: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0lNMDAwOTczNl9fMjA1ODg0LnBkZg==/IM0009736__205884.pdf; instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0VCQV9GQV9GcmVpYXVmc3RlbGx1bmdfcnVuZF91bmRfb3ZhbF9fNDUwMDUucGRm/EBA_FA_Freiaufstellung_rund_und_oval__45005.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://katalog.aco-haustechnik.de/Home/Produkte/Clean/Fettabscheider/Freiaufstellung/Vollentsorgung/Runde-Bauform-Polyethylen-PE-HD/Hydrojet-RAE-Ausbaustufe-3; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; LOD: LOD 400; Manufacturer: ACO; Model: NS 15; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS15
Type - Materials and Finishes - RSen_C_material: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ME_PE_hydro jet rae extension stage 3_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: NS15
Constraints - clearance_zone: no; DN_sanitary: yes; filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; OD_sanitary: no; Offset: 0 mm; right: yes; sight_glass: yes
Dimensions - Area: 29.2464 m2; D: 200 mm; D1: 1920 mm; D2: 1815 mm; D3: 1775 mm; D4: 1815 mm; disposalpump_angle: 27 deg; disposalpump_OD: 110 mm; disposalpump_X: 1122.5 mm; disposalpump_Z: 135 mm; DN: 200 mm; H: 2050.5 mm; H1: 1765 mm; H2: 1665 mm; H3: 2200 mm; H4: 2400 mm; inlet_length: 1110 mm; L1: 2130 mm; L2: 60 mm; L3: 200 mm; outlet_length: 1130 mm; Volume: 0.0486687 m3
Electrical - Loads - RSen_E_c01_apparent_power_phase_1: 2300 W; RSen_E_c01_apparent_power_phase_2: 2300 W; RSen_E_c01_apparent_power_phase_3: 2300 W
Electrical Engineering - RSen_E_c01_apparent_power: 6900 W; RSen_E_connected_fase: 1
General - RSen_P_c01_diameter: 200 mm; RSen_P_c02_diameter: 200 mm; RSen_P_c03_diameter: 100 mm; RSen_P_c04_diameter: 20 mm; RSen_P_c05_diameter: 65 mm
Identity Data - Mark: 9; RSen_C_code_article: 3515.73.82; RSen_C_code_gtin: 04002626131126; RSen_C_description: ACO Fettabscheid. Hydrojet RAE NS15 Dirabsg.+HD-Rg.rd.rechts
Mechanical - RSen_P_c04_flow: 0 m3/s; System Classification: Sanitary,Vent,Domestic Cold Water,Other,Controls,Power
Model Properties - clearance_back: 1010 mm; clearance_entry: 2065 mm; clearance_exit: 1565 mm; clearance_front: 1560 mm; clearance_top: 3000 mm; D_drain: 76 mm; DN_drain: 65 mm; drain_X: 215 mm; drain_Y: 280.6 mm; drain_Z: 2097 mm; motor_position: 130 deg; motor_Y: 961 mm; motor_Z: 828.5 mm; switchbox_position: 135 deg; switchbox_Y: 1006.5 mm; switchbox_Z: 1805.5 mm
Other - cold_water_connector: cw in; connector_escape_message: Nicht verwenden; extension_stage_lookup_table_name: eco-jet_rae_extension_stage_3; Family: ME_PE_hydro jet rae extension stage 3_ACO: NS15; Family and Type: ME_PE_hydro jet rae extension stage 3_ACO: NS15; help_connected_phase: 3; L2_half: 30 mm; lookup_table_name: ecojet_r_basic; no_option: 0; option: 1; options_lookup_table_name: ecojet_r_options; R: 100 mm; R4: 907.5 mm; Type: ME_PE_hydro jet rae extension stage 3_ACO: NS15; Type Id: ME_PE_hydro jet rae extension stage 3_ACO: NS15; vent_DN: 100 mm; vent_OD: 110 mm
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 3.61 m3; overall_capacity: 0.8 m3; sludge_trap_capacity: 1.95 m3
Structural - RSen_S_gross_mass: 4052; RSen_S_net_mass: 442

# IfcFlowTerminal: std, ZZZ_do not use_ME_PE_ecojet_r_options_ACO:std:20028
In: Level 1
Type - PredefinedType: GREASEINTERCEPTOR; Material: Plastic, White, HDPE, Red, HDPE, Black
Type - Identity Data - Manufacturer: ACO; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_ecojet_r_options_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; Offset: 0 mm; right: yes; sight_glass: yes; Moves With Nearby Elements: no
Dimensions - acces_exit_X: 656.5 mm; access_entry_bottom_radius: 230 mm; access_entry_radius: 192.5 mm; access_entry_X_position: 656.5 mm; Area: 24.7569 m2; cover_Z: 2130.5 mm; D: 200 mm; D1: 1920 mm; D2: 1815 mm; D3: 1775 mm; D4: 1815 mm; disposalpump_angle: 27 deg; disposalpump_flange_OD: 220 mm; disposalpump_flange length: 22 mm; disposalpump_OD: 110 mm; disposalpump_X: 1122.5 mm; disposalpump_Z: 135 mm; DN: 200 mm; H: 2050.5 mm; H1: 1765 mm; H2: 1665 mm; H3: 2200 mm; H4: 2400 mm; inlet_length: 1110 mm; L1: 2130 mm; L2: 60 mm; L3: 200 mm; logo_Z: 1082 mm; outlet_length: 1130 mm; rib_number: 2; rib_thickness: 25 mm; rib_total_thickness: 57.5 mm; rib1_Z: 785.75 mm; rib2_Z: 1361.25 mm; vent_X: 210 mm; vent_Y: 500 mm; Volume: 5.65943 m3; waterinlet_angle: -15 deg; waterinlet_OD: 90 mm; waterinlet_X: 1025.5 mm; waterinlet_Z: 1962.5 mm
General - RSen_P_c01_diameter: 200 mm; RSen_P_c02_diameter: 200 mm
Identity Data - Mark: 10
Model Properties - glass_position: 90 deg; glass_X: 907.5 mm; glass_Z: 1606.5 mm; grease_measure_end_angle: 85 deg; grease_measure_start_angle: 90 deg; grease_measure_X: 200 mm; grease_measure_Y: 500 mm; grease_measure_Z: 2050.5 mm; heatrod_position: 90 deg; heatrod_Z: 1237.5 mm
Other - bottom_part_Z: 760.75 mm; bottom_plate: yes; Family: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; Family and Type: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; filling_device_option: 0; grease_measure_option: 0; heatrod_option: 1; L2_half: 30 mm; logo_diameter: 1775 mm; logo_position: 90 deg; logo_radius: 887.5 mm; lookup_table_name: ecojet_r_basic; middle_part_Z: 1386.25 mm; options_lookup_table_name: ecojet_r_options; R: 100 mm; R4: 907.5 mm; sight_glass_option: 0; Type: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; type_index: 15; Type Id: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; vent_DN: 100 mm; vent_length: 50 mm; vent_OD: 110 mm; waterinlet_end_angle: 10 deg; waterinlet_height: 220.5 mm; waterinlet_start_angle: 195 deg
Phasing - Phase Created: New Construction

# IfcWindow: std, ZZZ_do not use_ME_PE_viewing window Ecojet_ACO:std:20034
In: Level 1
Type - Description: Viewing window; ParameterTakesPrecedence: no; Sizeable: no; Material: HDPE, Red, HDPE, Black, HDPE, Grey
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC011162; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Viewing window; LOD: LOD 400; Manufacturer: ACO; Model: ACO viewing window; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Nominal width: DN 200; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO
Type - Structural - RSen_S_net_mass: 5
OverallHeight: 75 mm; OverallWidth: 250 mm
Pset_WindowCommon - Reference: std; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ACO
BaseQuantities - Area: 0.0878948 m2
Constraints - Moves With Nearby Elements: no; Offset: 1606.5 mm
Dimensions - Area: 0.0878948 m2; Volume: 0.00175086 m3
Identity Data - Mark: 11; RSen_C_code_article: 3300.11.10; RSen_C_code_gtin: 04002626130280; RSen_C_description: ACO Schauglas LW 200 f. Eco-Jet-O,-OD,-R,-RD
Other - Family: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; Family and Type: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; option: 0; Type: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; Type Id: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std
Phasing - Phase Created: New Construction
